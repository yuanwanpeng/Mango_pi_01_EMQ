# Keil uVision project Mango_pi_01.uvprojx, settings and files
target Mango_pi_01 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Mango_pi_01 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\HARDWARE\BUTTON;..\HARDWARE\BUZZER;..\HARDWARE\LCD12864;..\HARDWARE\DELAY;..\HARDWARE\RELAY;..\HARDWARE\24C0X;..\HARDWARE\HUMI;..\HARDWARE\LED;..\HARDWARE\SIM800C;..\HARDWARE\ESP8266;..\HARDWARE\AM2320;..\HARDWARE\BOARD_INFO;..\PROTOCOL;..\CJSON;..\PROTOCOL\MQTTPacket;..\ALIOT
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: Strategy.c GPRS.c main.c user_diskio.c fatfs.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c malloc.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: uart.c
    ..//Src/: system_stm32f1xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group HARDWARE
    ../HARDWARE/BUTTON/: button.c
    ../HARDWARE/BUZZER/: BUZZER.c
    ../HARDWARE/LCD12864/: LCD12864.c TypeFace.c LCD12864_Display_Menu_Set_Strategy.c LCD12864_Display_Menu.c LCD12864_Display_Menu_HUMI_Compensation.c LCD12864_Display_Menu_Max_Route.c LCD12864_Display_Menu_Route_Reset.c LCD12864_Display_Menu_Set_Strategy_Info.c LCD12864_Display_Menu_Set_Time.c LCD12864_Display_Menu_Stroking_Cycle.c LCD12864_Display_Menu_Delay_Inspection.c
    ../HARDWARE/DELAY/: delay.c
    ../HARDWARE/RELAY/: Check_Stroking_Cycle.c Monitor_IN1.c relay.c
    ../HARDWARE/24C0X/: 24C0x.c IIC.c
    ../HARDWARE/HUMI/: HUMI.c
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/SIM800C/: SIM800C.C SIM800C_Send_State_data.c SIM800C_Scheduler_data.c SIM800C_Recv_Onenet_data.c
    ../HARDWARE/ESP8266/: HTTP_CODE.c
    ../HARDWARE/AM2320/: AM2320.c
    ../HARDWARE/BOARD_INFO/: board_info.c
  group PROTOCOL
    ../PROTOCOL/: Mqtt.c
    ../PROTOCOL/MQTTPacket/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c transport.c
  group CJSON
    ../CJSON/: cJSON.c
  group ALIOT
    ../ALIOT/: ALIOT.c
software components: CMSIS:CORE 5.0.1
